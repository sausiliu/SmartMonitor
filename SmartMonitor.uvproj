# Keil uVision project SmartMonitor.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1
  c define: RVDS_ARMCM3_LM3S102
  c include: .\Source;.\Source\User;.\Source\FreeRTOS\include;.\Source\Common\include;.\Source\User\STM32F10xFWLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./Source/User/: STM32F10x.s
    ./Source/Common/drivers/ST/STM32F10xFWLib/src/: cortexm3_macro_rvds.s
    ./Source/User/STM32F10xFWLib/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_iwdg.c stm32f10x_exti.c
  group driver
    ./Source/User/driver/: ultrasonic_rangefinder.c infrared_motition.c alertor.c
  group FreeRTOS files
    ./Source/FreeRTOS/: tasks.c queue.c list.c
    ./Source/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./Source/FreeRTOS/portable/MemMang/: heap_2.c
  group User
    ./Source/User/ParTest/: ParTest.c
    ./Source/User/serial/: serial.c
    ./Source/User/: timertest.c main.c spi_flash.c
    ./Source/Common/Minimal/: semtest.c BlockQ.c blocktim.c comtest.c death.c flash.c integer.c PollQ.c
